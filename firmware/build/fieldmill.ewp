# IAR project fieldmill.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496RG ST STM32L496RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4; STM32L496xx; USBD_SOF_DISABLED
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: fieldmill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l496xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: DADC.cpp DADC.h DCIC.cpp DCIC.h Demod.cpp Demod.h DGPIO.cpp DGPIO.h DMotor.cpp DMotor.h DSpi.cpp DSpi.h DTimers.cpp DTimers.h interrupts.cpp interrupts.h main.cpp usb_cdc.h UsbDebug.cpp UsbDebug.h
    ./: stm32l496xG.icf
  group CMSIS
    ../src/: startup_stm32l496xx.s stm32l496xx.h stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h
  group libusb_stm32
    ../src/: usb.h usb_std.h usbd_core.c usbd_core.h usbd_stm32l476_otgfs.c
